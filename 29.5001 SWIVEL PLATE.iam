# Autodesk Inventor assembly: 29.5001 SWIVEL PLATE
## iProperties
Created: 2007-07
Part Number: 29.5001 SWIVEL PLATE
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
